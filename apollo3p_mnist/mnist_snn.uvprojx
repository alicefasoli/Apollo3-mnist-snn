# Keil uVision project mnist_snn.uvprojx, settings and files
target project (6180000::V6.18::ARMCLANG)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mnist_snn
  AfterMake: fromelf --bin --output Objects\blinky.bin Objects\mnist_snn.axf
  AfterMake: fromelf -cedrst --output Objects\mnist_snn.txt Objects\mnist_snn.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  group src
    ./src/: main.c parameters.h network_values.h classify.h neuron.h actual_image.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 1.3.0
